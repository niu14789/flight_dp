# Keil uVision project flight.uvprojx, settings and files
target flight (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flight +hex
  AfterMake: drone_output.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Lib\CMSIS\GD\GD32F30x\Include;..\Lib\CMSIS;..\Lib\GD32F30x_standard_peripheral\Include;..\Utilities;..\;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;..\sensor\Dps310;..\sensor\Gps;..\sensor\ICM20600;..\sensor\Calibration;..\sensor\ST480;..\driver\SPI;..\driver\InternalFlash;..\driver\Parameter;..\driver\Usart;..\user\TEST;..\link;..\driver\PWM;..\driver\led;..\driver\adc;..\driver\sbus;..\Lib\GD32F30x_usbd_driver\Include;..\driver\CdcAcm;..\driver\I2C;..\common\file_system;..\driver\icm;..\driver\common;..\driver\irom;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20002000 size 0xb000
  link misc: --keep __FS_*;--keep __FS_SHELL_*
  group basic
    ../Lib/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
    ../Lib/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../user/: main.c gd32f30x_it.c
  group gd32lib
    ../Lib/GD32F30x_standard_peripheral/Source/: gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c gd32f30x_adc.c
  group fs
    ../common/file_system/: f_open.c f_shell.c fs_inode.c fs_init.c fs_allocate.c
  group driver
    ../driver/Usart/: usart.c
    ../driver/icm/: icm206.c
    ../driver/led/: led.c
    ../driver/st480/: st480.c
    ../driver/dp310/: dps310.c
    ../driver/PWM/: pwm.c
  group application
    ../driver/gps/: gps_basic.c gps_hard.c
    ../driver/common/: common.c
    ../driver/log/: log.c
  group algo
    ../driver/algo/: algo.c
software components: CMSIS:CORE 5.1.2
